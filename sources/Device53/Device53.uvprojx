# Keil uVision project Device53.uvprojx, settings and files
target S8-53 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F207ZCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: S8-53
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx, __cplusplus
  c misc: --cpp
  c include: ..\STM32Cube_FW_F2\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\STM32Cube_FW_F2\Drivers\STM32F2xx_HAL_Driver\Inc;..\STM32Cube_FW_F2\Drivers\STM32F2xx_HAL_Driver\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\system;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include\ipv4;..\STM32Cube_FW_F2\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F2\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include\lwip;..\STM32Cube_FW_F2\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\S8-53.sct
  group HAL
    ../STM32Cube_FW_F2/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c
    ../STM32Cube_FW_F2/Drivers/STM32F2xx_HAL_Driver/Inc/: stm32f2xx_hal_crc.h
  group USBH
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group LwIP
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/core/: udp.c tcp_out.c tcp_in.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c inet_chksum.c def.c ip.c timeouts.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c igmp.c icmp.c autoip.c dhcp.c etharp.c ip4_frag.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netdb.c netbuf.c err.c api_msg.c api_lib.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/include/lwip/: opt.h
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group libs
    ./src/libs/: stm32f2xx_it.h startup_stm32f207xx.s system_stm32f2xx.c stm32f2xx_hal_conf.h usbh_conf.h ffconf.h usbd_cdc_interface.h usbd_conf.h usbd_desc.c usbd_desc.h app_ethernet.h ethernetif.h lwipopts.h app_ethernet.cpp stm32f2xx_hal_msp.cpp usbd_cdc_interface.cpp usbd_conf.cpp usbh_conf.cpp stm32f2xx_it.cpp ethernetif.cpp
  group src
    ./src/: main.h defines.h Tables.h Globals.h main2.s Log.h defines.cpp Tables.cpp main.cpp Globals.cpp Log.cpp
  group Display
    ./src/Display/: Display.cpp Display.h DisplayPrimitives.h Colors.h Painter.cpp Painter.h DisplayTypes.h Grid.cpp Grid.h Math3D.h WelcomeScreen.h PainterMem.h Symbols.h WelcomeScreen.cpp PainterText.cpp DisplayPrimitives.cpp Colors.cpp PainterC.h PainterMem.cpp Math3D.cpp
  group Display/font
    ./src/Display/font/: Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font.cpp
  group Ethernet
    ./src/Ethernet/: Ethernet.h TcpSocket.h Ethernet.cpp TcpSocket.cpp
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.cpp FlashDrive.h
  group FPGA
    ./src/FPGA/: DataStorage.cpp DataStorage.h FPGA.cpp FPGA.h FPGA_Types.h FPGA_Calibration.cpp FPGA_Settings.cpp
  group Hardware
    ./src/Hardware/: ADC.cpp ADC.h FLASH.h FSMC.h Hardware.h MSP_USBH.c RTC.cpp RTC.h Sound.cpp Sound.h Timer.h FLASH.cpp FSMC.cpp Hardware.cpp Timer.cpp
  group Menu
    ./src/Menu/: FileManager.h Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsGraphics.h MenuItemsLogic.h Menu_reference.txt MenuFunctions.cpp FileManager.cpp MenuDrawing.cpp MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: Definition.h PageCursors.h PageHelp.h PageMemory.h HelpContent.h HelpContentPages.h PageMeasures.h Definition.cpp HelpContent.cpp PageChannels.cpp PageCursors.cpp PageDebug.cpp PageDisplay.cpp PageHelp.cpp PageMeasures.cpp PageMemory.cpp PageService.cpp PageTime.cpp PageTrig.cpp
  group Panel
    ./src/Panel/: Controls.h Panel.cpp Panel.h Controls.cpp PanelFunctions.cpp
  group Settings
    ./src/Settings/: SettingsTypes.h Settings.h SettingsChannel.h SettingsDisplay.h SettingsMemory.h SettingsTime.h SettingsService.h SettingsCursors.h SettingsDebug.h SettingsTrig.h SettingsMath.h Settings.cpp SettingsChannel.cpp SettingsCursors.cpp SettingsDebug.cpp SettingsMeasures.h SettingsDisplay.cpp SettingsService.cpp SettingsMemory.cpp SettingsTime.cpp SettingsMeasures.cpp
  group Utils
    ./src/Utils/: Strings.h Map.h Generator.h GlobalFunctions.h Math.h Measures.h ProcessingSignal.h Stack2500uint16.cpp Stack2500uint16.h CreateTables.py TablesLog.h TablesWindow.h Generator.cpp GlobalFunctions.cpp Map.cpp Math.cpp Measures.cpp ProcessingSignal.cpp Strings.cpp
  group VCP
    ./src/VCP/: VCP.h VCP.cpp
  group VCP/SCPI
    ./src/VCP/SCPI/: commonSCPI.h controlSCPI.h SCPI.h SCPI.cpp channelSCPI.cpp commonSCPI.cpp controlSCPI.cpp displaySCPI.cpp tbaseSCPI.cpp trigSCPI.cpp
  group FatFS
    ../STM32Cube_FW_F2/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group USBD
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
