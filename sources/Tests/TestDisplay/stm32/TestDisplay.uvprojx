# Keil uVision project TestDisplay.uvprojx, settings and files
target TestDisplay (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F217IGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TestDisplay
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx
  c include: .\src;..\..\..\STM32Cube_FW_F2\Drivers\STM32F2xx_HAL_Driver\Inc;.\src\libs;..\..\..\STM32Cube_FW_F2\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\STM32Cube_FW_F2\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Display
    ./src/Display/: Display.c Display.h Painter.c Painter.h Colors.c Colors.h DisplayTypes.h PainterC.h
  group Hardware
    ./src/Hardware/: Hardware.c Hardware.h FSMC.c FSMC.h Timer.c Timer.h DisplayHardware.inc
  group libs
    ./src/libs/: startup_stm32f207xx.s stm32f2xx_hal_conf.h stm32f2xx_hal_msp.c stm32f2xx_it.c stm32f2xx_it.h system_stm32f2xx.c
  group src
    ./src/: main.c defines.c defines.h Globals.c Globals.h config.h Log.h
  group Settings
    ./src/Settings/: Settings.c Settings.h SettingsTypes.h
  group HAL
    ../../../STM32Cube_FW_F2/Drivers/STM32F2xx_HAL_Driver/Inc/: stm32f2xx_hal_gpio.h stm32f2xx_hal.h stm32f2xx_hal_cortex.h stm32f2xx_hal_rcc.h stm32f2xx_hal_tim.h stm32f2xx_hal_sram.h stm32f2xx_hal_dma.h stm32f2xx_hal_pwr.h stm32f2xx_hal_rcc_ex.h stm32f2xx_hal_tim_ex.h stm32f2xx_ll_fsmc.h
    ../../../STM32Cube_FW_F2/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_gpio.c stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_tim.c stm32f2xx_hal_sram.c stm32f2xx_hal_dma.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_fsmc.c
