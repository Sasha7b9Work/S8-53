# Keil uVision project S8-53.uvprojx, settings and files
target S8-53 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F217IGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: S8-53
  AfterMake: fromelf --bin --output .\s8-53.bin .\out\s8-53.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx
  c misc: --C99
  c include: ..\STM32Cube_FW_F2\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\STM32Cube_FW_F2\Drivers\STM32F2xx_HAL_Driver\Inc;..\STM32Cube_FW_F2\Drivers\STM32F2xx_HAL_Driver\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\STM32Cube_FW_F2\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\system;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include\ipv4;..\STM32Cube_FW_F2\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F2\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\libs;..\STM32Cube_FW_F2\Middlewares\Third_Party\LwIP\src\include\lwip;..\STM32Cube_FW_F2\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\S8-53.sct
  group HAL
    ../STM32Cube_FW_F2/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c stm32f2xx_hal_pwr.c
  group USBH
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group LwIP
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/core/: udp.c tcp_out.c tcp_in.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c inet_chksum.c def.c ip.c timeouts.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c igmp.c icmp.c autoip.c dhcp.c etharp.c ip4_frag.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netdb.c netbuf.c err.c api_msg.c api_lib.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/include/lwip/: opt.h
    ../STM32Cube_FW_F2/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group libs
    ./src/libs/: stm32f2xx_it.c stm32f2xx_it.h startup_stm32f207xx.s system_stm32f2xx.c stm32f2xx_hal_conf.h stm32f2xx_hal_msp.c usbh_conf.c usbh_conf.h ffconf.h usbd_cdc_interface.c usbd_cdc_interface.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h app_ethernet.c app_ethernet.h ethernetif.c ethernetif.h lwipopts.h
  group src
    ./src/: main.h main.c defines.h Tables.c Tables.h defines.c Globals.c Globals.h main2.s Log.c Log.h
  group Display
    ./src/Display/: Display.h DisplayPrimitives.h Colors.h Painter.h Colors.c Display.c DisplayPrimitives.c DisplayTypes.h Grid.c Grid.h Math3D.c Math3D.h Painter.c WelcomeScreen.c WelcomeScreen.h PainterText.c PainterText.h PainterMem.c PainterMem.h Symbols.h
  group Display/font
    ./src/Display/font/: Font.c Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group Ethernet
    ./src/Ethernet/: Ethernet.c Ethernet.h TcpSocket.c TcpSocket.h
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.c FlashDrive.h
  group FPGA
    ./src/FPGA/: DataStorage.h DataStorage.c FPGA.h FPGA_Types.h FPGA.c FPGA_Calibration.c FPGA_Calibration.h FPGA_Settings.c
  group Hardware
    ./src/Hardware/: Hardware.c Hardware.h FLASH.h FLASH.c FSMC.c FSMC.h Sound.c Sound.h ADC.c ADC.h MSP_USBH.c RTC.cpp RTC.h Timer.c Timer.h
  group Menu
    ./src/Menu/: FileManager.c FileManager.h Menu.c Menu.h MenuDrawing.c MenuDrawing.h MenuFunctions.c MenuFunctions.h MenuItems.h MenuItemsGraphics.c MenuItemsGraphics.h MenuItemsLogic.c MenuItemsLogic.h
  group Menu/Pages
    ./src/Menu/Pages/: Definition.c Definition.h PageChannels.c PageCursors.c PageCursors.h PageDebug.c PageDisplay.c PageHelp.c PageHelp.h PageMeasures.c PageMemory.c PageMemory.h PageService.c PageTime.c PageTrig.c PageServiceMath.h HelpContent.h HelpContent.c HelpContentPages.h
  group Panel
    ./src/Panel/: Controls.c Controls.h Panel.c Panel.h PanelFunctions.c
  group Settings
    ./src/Settings/: SettingsTypes.h Settings.c Settings.h SettingsChannel.c SettingsChannel.h SettingsDisplay.c SettingsDisplay.h SettingsMemory.c SettingsMemory.h SettingsTime.c SettingsTime.h SettingsService.c SettingsService.h SettingsCursors.c SettingsCursors.h SettingsDebug.c SettingsDebug.h SettingsTrig.h SettingsMath.h
  group Utils
    ./src/Utils/: Strings.c Strings.h Map.c Map.h Generator.c Generator.h GlobalFunctions.c GlobalFunctions.h Math.c Math.h Measures.c Measures.h ProcessingSignal.c ProcessingSignal.h Stack2500uint16.cpp Stack2500uint16.h CreateTables.py TablesLog.h TablesSin.h TablesWindow.h
  group VCP
    ./src/VCP/: VCP.h VCP.c
  group VCP/SCPI
    ./src/VCP/SCPI/: channelSCPI.c commonSCPI.c commonSCPI.h controlSCPI.c controlSCPI.h displaySCPI.c SCPI.c SCPI.h trigSCPI.c tbaseSCPI.c
  group FatFS
    ../STM32Cube_FW_F2/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
    ../STM32Cube_FW_F2/Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group USBD
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../STM32Cube_FW_F2/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
